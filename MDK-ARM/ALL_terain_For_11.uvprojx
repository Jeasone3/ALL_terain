# Keil uVision project ALL_terain_For_11.uvprojx, settings and files
target ALL_terain_For_11 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ALL_terain_For_11 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Int/Int_Beep;../Int/Int_Motor;../Int/Int_MPU6050;../Int/Int_OLED;../Int/Int_Track;../Com/Com_Attitude;../Com/Com_Delay_us;../Com/Com_IIC;../Com/Com_IMU_Config;../Com/Com_Limit;../Com/Com_PID;../App/IMU_Task;../App/Mode_FSM;../App/Track_Task;../App/Route;../App/Debug_Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App/Track_Task
    ../App/Track_Task/: Track_Task.c Track_Task.h
  group App/IMU_Task
    ../App/IMU_Task/: IMU_Task.c IMU_Task.h
  group App/Mode_FSM
    ../App/Mode_FSM/: Mode_FSM.c Mode_FSM.h
  group App/Route
    ../App/Route/: Route.c Route.h
  group App/Debug_Log
    ../App/Debug_Log/: Debug_Log.c Debug_Log.h
  group Com/PID
    ../Com/Com_PID/: Com_pid.c Com_pid.h
  group Com/Limit
    ../Com/Com_Limit/: Com_Limit.c Com_Limit.h
  group Com/Delay_us
    ../Com/Com_Delay_us/: Delay_us.c Delay_us.h
  group Com/Attitude
    ../Com/Com_Attitude/: Attitude.c Attitude.h
  group Com/IIC
    ../Com/Com_IIC/: iic.c iic.h
  group Com/IMU_Config
    ../Com/Com_IMU_Config/: IMU_Config.h
  group Int/Motor
    ../Int/Int_Motor/: motor.c motor.h
  group Int/Track
    ../Int/Int_Track/: Int_Track.c Int_Track.h
  group Int/OLED
    ../Int/Int_OLED/: Int_OLED.c Int_OLED.h OLED_Port.c OLED_Port.h oledfont.c oledfont.h
  group Int/MPU6050
    ../Int/Int_MPU6050/: Int_MPU6050.c Int_MPU6050.h
  group Int/Beep
    ../Int/Int_Beep/: Int_Beep.c Int_Beep.h
software components: CMSIS:CORE 4.3.0
